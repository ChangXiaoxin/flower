# Keil uVision project flower.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: flower +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\USER;.\HARDWARE;.\CMSIS;.\FWLIB\inc;.\SYSTEM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./USER/: init.c main.c stm32f10x_it.c task.c taskdo.c blink.c rgbled.c flower.c
  group HARDWARE
    ./HARDWARE/: timer.c ws2812b.c touch.c petals.c servo.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTUP
    ./CMSIS/startup/arm/: startup_stm32f10x_md.s
  group SYSTEM
    ./SYSTEM/: delay.c sys.c usart.c
  group README
    ./: README.md
